# Keil uVision project ADC.uvprojx, settings and files
target NUCLEO-L412B (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ADC
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Scr
    ./: RCC.c Delay.c USART.c retarget.c main.c ADC.c stm32l4xx_it.c TIMER.c DMA.c
  group Inc
    ./: RCC.h Delay.h USART.h ADC.h TIMER.h DMA.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.1
